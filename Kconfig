## Kconfig
```kconfig
config LED_WIDGET
    bool "Enable RGB LED widget for showing battery and output status"

if LED_WIDGET

config LED
    default y

endif
```
